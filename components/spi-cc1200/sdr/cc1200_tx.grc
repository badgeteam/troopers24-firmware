options:
  parameters:
    author: hammel
    generate_options: qt_gui
    id: cc1200_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 3e3
  states: {}
- name: f
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: foff
  id: variable
  parameters:
    value: samp_rate/4
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12e5
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*3.14159*(deviation/samp_rate)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 1/math.pi
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: foff
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '2'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/demod.fifo
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate / bit_rate)
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: fosphor_qt_sink_c_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: f
    freq_span: samp_rate
  states: {state: disabled}
- name: fosphor_qt_sink_c_0_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: f-foff
    freq_span: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: deviation *2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 'deviation '
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'True'
    type: UDP_SERVER
  states: {state: disabled}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '1234'
    tcp_no_delay: 'True'
    type: UDP_SERVER
  states: {}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '89.9'
    bw0: samp_rate
    freq0: f-foff
    gain0: '89.9'
    if_gain0: '89.9'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '10'
    bw0: samp_rate
    dc_offset_mode0: '2'
    freq0: f-foff
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '10'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Quadrature
    label2: Amplitude
    name: '"Quadrature"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_chan: '1'
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Quadrature
    name: '"Quadrature"'
    size: '1024'
    srate: samp_rate
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bits
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: bits
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bits
  states: {}

connections:
- [analog_frequency_modulator_fc_0_0, '0', blocks_multiply_xx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', blocks_float_to_complex_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_0_0, '0', virtual_sink_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_float_to_complex_0, '0', blocks_file_sink_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_null_sink_0, '0']
- [blocks_float_to_complex_1, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', fosphor_qt_sink_c_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', osmosdr_sink_0_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_1, '1']
- [blocks_repeat_0_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [blocks_repeat_0_0, '0', blocks_float_to_complex_1, '0']
- [blocks_repeat_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0_0, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [network_socket_pdu_0_0, pdus, pdu_pdu_to_tagged_stream_0_0, pdus]
- [osmosdr_source_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [osmosdr_source_0, '0', fosphor_qt_sink_c_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_char_to_float_0_0, '0']
- [virtual_source_0, '0', blocks_repeat_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
